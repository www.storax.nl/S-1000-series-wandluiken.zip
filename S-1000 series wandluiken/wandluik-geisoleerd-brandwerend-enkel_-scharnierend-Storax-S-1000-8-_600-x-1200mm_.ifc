Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 692e9dac-f48a-4aeb-84c1-105a0fd9c5ef.ifc
Time: 2026-08-11T08:49:56
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, wandluik geïsoleerd brandwerend enkel, scharnierend Storax S 1000-8 (600 x 1200mm)
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 60 min
Pset_Data - WUID: AgAAADx6QrYDAAAAyesCAAWhVAEA92ABAInDAABL7AIA_eoCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAADx6QrYDAAAAyesCAAWhVAEA92ABAInDAABL7AIA_eoCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); dagmaathoogte: 1150 mm; gewicht per st: 15,5 kg/st; STABU2: 43.31.20; inbouwhoogte: 1210 mm; brandwerendheid E: 60 min; breedte: 648 mm; dikte: 45 mm; NAA.K.T: samengesteld_product_kozijn; kleur: RAL 9010; serie: Brandwerende wandluiken; afsluitbaar: True; inbouwbreedte: 610 mm; hoogte: 1248 mm; merk: Storax; inbouwdiepte: 45 mm; type: S 1000-8; dagmaatbreedte: 530 mm; omranding: staal; luik: staal
