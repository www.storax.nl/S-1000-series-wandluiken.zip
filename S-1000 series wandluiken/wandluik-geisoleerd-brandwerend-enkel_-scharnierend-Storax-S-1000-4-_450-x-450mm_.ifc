Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: cb83190f-7bed-4ee8-9da5-9a6688d22473.ifc
Time: 2026-08-11T08:54:28
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, wandluik geïsoleerd brandwerend enkel, scharnierend Storax S 1000-4 (450 x 450mm)
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 60 min
Pset_Data - WUID: AgAAADzvQ7YDAAAAyesCAAWhVAEA92ABAInDAABL7AIAaOsCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAADzvQ7YDAAAAyesCAAWhVAEA92ABAInDAABL7AIAaOsCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); dagmaathoogte: 400 mm; gewicht per st: 6 kg/st; STABU2: 43.31.20; inbouwhoogte: 460 mm; brandwerendheid E: 60 min; breedte: 498 mm; dikte: 45 mm; NAA.K.T: samengesteld_product_kozijn; kleur: RAL 9010; serie: Brandwerende wandluiken; afsluitbaar: True; inbouwbreedte: 460 mm; hoogte: 498 mm; merk: Storax; inbouwdiepte: 45 mm; type: S 1000-4; dagmaatbreedte: 380 mm; omranding: staal; luik: staal
