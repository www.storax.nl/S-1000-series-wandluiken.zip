Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 32af251c-9a6f-40ff-a4d3-36a5f900c551.ifc
Time: 2026-08-11T08:53:16
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, wandluik geïsoleerd brandwerend enkel, scharnierend Storax S 1000-7 (600 x 900mm)
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 60 min
Pset_Data - WUID: AgAAADxGQ7YDAAAAyesCAAWhVAEA92ABAInDAABL7AIAwesCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAADxGQ7YDAAAAyesCAAWhVAEA92ABAInDAABL7AIAwesCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); dagmaathoogte: 850 mm; gewicht per st: 12,3 kg/st; STABU2: 43.31.20; inbouwhoogte: 910 mm; brandwerendheid E: 60 min; breedte: 648 mm; dikte: 45 mm; NAA.K.T: samengesteld_product_kozijn; kleur: RAL 9010; serie: Brandwerende wandluiken; afsluitbaar: True; inbouwbreedte: 610 mm; hoogte: 948 mm; merk: Storax; inbouwdiepte: 45 mm; type: S 1000-7; dagmaatbreedte: 530 mm; omranding: staal; luik: staal
