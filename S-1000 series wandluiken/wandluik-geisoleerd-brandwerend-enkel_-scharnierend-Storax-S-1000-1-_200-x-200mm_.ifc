Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: aee75490-5579-44fb-8c7e-2816417ff117.ifc
Time: 2026-08-11T08:49:00
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, wandluik geïsoleerd brandwerend enkel, scharnierend Storax S 1000-1 (200 x 200mm)
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 60 min
Pset_Data - WUID: AgAAADxmQrYDAAAAyesCAAWhVAEA92ABAInDAABL7AIA4eoCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAADxmQrYDAAAAyesCAAWhVAEA92ABAInDAABL7AIA4eoCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); dagmaathoogte: 150 mm; gewicht per st: 1,95 kg/st; STABU2: 43.31.20; inbouwhoogte: 210 mm; brandwerendheid E: 60 min; breedte: 248 mm; dikte: 45 mm; NAA.K.T: samengesteld_product_kozijn; kleur: RAL 9010; serie: Brandwerende wandluiken; afsluitbaar: True; inbouwbreedte: 210 mm; hoogte: 248 mm; merk: Storax; inbouwdiepte: 45 mm; type: S 1000-1; dagmaatbreedte: 130 mm; omranding: staal; luik: staal
