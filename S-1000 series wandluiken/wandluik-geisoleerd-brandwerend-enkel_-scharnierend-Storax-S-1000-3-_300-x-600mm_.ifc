Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: f38ddb8d-2d5a-4a4e-8edb-69a9edc96999.ifc
Time: 2026-08-11T08:54:17
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, wandluik geïsoleerd brandwerend enkel, scharnierend Storax S 1000-3 (300 x 600mm)
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 60 min
Pset_Data - WUID: AgAAADyvQ7YDAAAAyesCAAWhVAEA92ABAInDAABL7AIAKOsCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAADyvQ7YDAAAAyesCAAWhVAEA92ABAInDAABL7AIAKOsCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); dagmaathoogte: 550 mm; gewicht per st: 5,53 kg/st; STABU2: 43.31.20; inbouwhoogte: 610 mm; brandwerendheid E: 60 min; breedte: 348 mm; dikte: 45 mm; NAA.K.T: samengesteld_product_kozijn; kleur: RAL 9010; serie: Brandwerende wandluiken; afsluitbaar: True; inbouwbreedte: 310 mm; hoogte: 648 mm; merk: Storax; inbouwdiepte: 45 mm; type: S 1000-3; dagmaatbreedte: 230 mm; omranding: staal; luik: staal
